options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: wifi_detect
    output_language: python
    title: 802.11a frame detection (Week 1)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: window_size
  id: variable
  parameters:
    comment: Nwin da autocorrelacao e da potencia
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: c[n] = |a[n]| / p[n]
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Sinal de teste (mesma pasta que este .grc)
    file: sts_test.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: in0 = atrasado e conjugado; in1 = atual
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Soma deslizante (autocorrelacao)
    decim: '1'
    taps: '[1.0]*int(window_size)'
    type: ccf
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    comment: Soma deslizante (potencia)
    decim: '1'
    taps: '[1.0]*int(window_size)'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: c[n]
    name: '"c[n]"'
    size: '2048'
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.5'
    ymin: '-0.1'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '1']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_1, '0', blocks_divide_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
